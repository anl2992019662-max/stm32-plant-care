# Keil uVision project PlantCare.uvprojx, settings and files
target PlantCare (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x08000000-0x0800F7FF) CLOCK(64000000) CPUTYPE("Cortex-M3")
  output: plant-care +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,__MICROLIB
  c misc: -std=c11 -Wall -Wextra -Werror -ffunction-sections -fdata-sections
  c include: ..\firmware\include;..\vendor\cmsis-device-f1\Include;..\vendor\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xF800
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\firmware\plant.sct
  link misc: --strict
  group Plant firmware
    ../firmware/src/: board.c codecs.c main.c oled.c plant.c startup.c storage_rtc.c
